## lvgl_rgb/Kconfig
```kconfig
menu "RGB Port Config"
	config RGB_MANAGER_ENABLED
		bool "Enable RGB port."
endmenu
```
